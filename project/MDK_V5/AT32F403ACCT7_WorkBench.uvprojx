# Keil uVision project AT32F403ACCT7_WorkBench.uvprojx, settings and files
target AT32F403ACCT7_WorkBench (6220000::V6.22::ARMCLANG)
  device: -AT32F403ACCT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403ACCT7_WorkBench +hex
  c flags: Optim=2 OneElfS=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: AT32F403ACCT7, USE_STDPERIPH_DRIVER, ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_LOOPUNROLL, AT_START_F403A_V1, PY32F403xD
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;../../middlewares/usbd_drivers/inc;../../libraries/cmsis/dsp/include;../../libraries/cmsis/dsp/PrivateInclude;..\..\middlewares\ltx\inc;..\..\middlewares\ltx\components\app;..\..\middlewares\ltx\components\debug;..\..\middlewares\ltx\components\log;..\..\middlewares\ltx\components\script;..\..\libraries\drivers\HAL\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c usb_app.c wk_acc.c wk_adc.c wk_debug.c wk_spi.c wk_tmr.c wk_usbfs.c wk_dma.c wk_gpio.c myAPP_system.c py32f4xx_hal_msp.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_gpio.c at32f403a_407_pwc.c at32f403a_407_adc.c at32f403a_407_spi.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_exint.c at32f403a_407_misc.c at32f403a_407_usb.c at32f403a_407_acc.c at32f403a_407_debug.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group middlewares/usbd_driver
    ../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group cmsis_dsp
    ../../libraries/cmsis/dsp/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../libraries/cmsis/dsp/Source/BayesFunctions/: BayesFunctions.c
    ../../libraries/cmsis/dsp/Source/CommonTables/: CommonTables.c
    ../../libraries/cmsis/dsp/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../libraries/cmsis/dsp/Source/ControllerFunctions/: ControllerFunctions.c
    ../../libraries/cmsis/dsp/Source/DistanceFunctions/: DistanceFunctions.c
    ../../libraries/cmsis/dsp/Source/FastMathFunctions/: FastMathFunctions.c
    ../../libraries/cmsis/dsp/Source/FilteringFunctions/: FilteringFunctions.c
    ../../libraries/cmsis/dsp/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../libraries/cmsis/dsp/Source/MatrixFunctions/: MatrixFunctions.c
    ../../libraries/cmsis/dsp/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../libraries/cmsis/dsp/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../libraries/cmsis/dsp/Source/SupportFunctions/: SupportFunctions.c
    ../../libraries/cmsis/dsp/Source/SVMFunctions/: SVMFunctions.c
    ../../libraries/cmsis/dsp/Source/TransformFunctions/: TransformFunctions.c
  group usbd_class
    ../src/: cdc_class.c cdc_desc.c
  group middlewares/ltx
    ../../middlewares/ltx/src/: ltx.c
    ../../middlewares/ltx/components/debug/: ltx_cmd.c ltx_param.c
    ../../middlewares/ltx/components/log/: ltx_log.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../middlewares/ltx/components/script/: ltx_script.c
    ../../middlewares/ltx/components/app/: ltx_app.c
  group HAL
    ../../libraries/drivers/HAL/src/: py32f4xx_hal.c py32f4xx_hal_cortex.c py32f4xx_hal_dma.c py32f4xx_hal_spi.c py32f4xx_hal_spi_ex.c system_py32f4xx.c
